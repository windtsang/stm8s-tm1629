# IAR project strength.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\work\softproject\led_show\FWlib\inc; E:\work\softproject\led_show\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: strength.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group Flib
    ../FWlib/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_uart1.c
  group User
    ../USER/: main.c tm1650.c
